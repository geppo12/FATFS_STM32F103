# IAR project FATFS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\FWLIB\cmsis\interface; ..\..\FWLIB\driver\interface; ..\..\USER\interface; ..\..\STM32_EVAL; ..\..\STM32_EVAL\common; ..\..\STM32_EVAL\stm3210b_eval; ..\..\STM32_EVAL\stm3210c_eval; ..\..\STM32_EVAL\stm3210e_eval; ..\..\STM32_EVAL\stm32100b_eval; ..\..\FATFS\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: FATFS.out
  ILINK.IlinkIcfFile: F:\Project\FATFS\FWLIB\cmsis\startup\generic_cortex_m3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group DOC
    ../../DOC/: History.txt
  group FATFS
    ../../FATFS/src/: diskio.c ff.c
  group FWLIB/CMSIS
    ../../FWLIB/cmsis/source/: core_cm3.c system_stm32f10x.c
  group FWLIB/CMSIS/STARTUP
    ../../FWLIB/cmsis/startup/: startup_stm32f10x_hd.s
  group FWLIB/DRIVER
    ../../FWLIB/driver/source/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_usart.c
  group STM32_EVAL
    ../../STM32_EVAL/STM3210E_EVAL/: stm3210e_eval_lcd.c
    ../../STM32_EVAL/: stm32_eval.c
  group USER
    ../source/: common.c delay.c FS_TEST.c fsmc_nand.c main.c stm32f10x_it.c
    ../../../../../../test/: getcmd.c
